FILESEXTRAPATHS:prepend := "${THISDIR}/platform-init:"

COMPATIBLE_MACHINE:ebaz4205-zynq7 = "ebaz4205-zynq7"